Commit message: change tcp, added tf for demo.launch

File: xarm_description/urdf/xarm6_with_gripper.urdf (robot description, URDF)
Before this commit: robot xarm6_with_gripper, 17 links, 16 joints
Joints:
- joint joint_tcp: origin xyz=0 0 0.172 rpy=0 0 0 -> xyz=0 0 0.122 rpy=0 0 0
